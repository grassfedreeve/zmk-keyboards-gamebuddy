## boards/shields/gamebuddy/Kconfig.defconfig
```kconfig
if SHIELD_GAMEBUDDY
            
config ZMK_KEYBOARD_NAME
    default "gamebuddy"

CONFIG_BT_CTLR_TX_PWR_PLUS_8=y

endif
```
